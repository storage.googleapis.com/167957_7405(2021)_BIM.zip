Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-03-01T13:49:57
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 01 13:49:57 2021 * Host: DESKTOP-JA1LLOH * Database: C:\Users\Vlad\AppData\Local\Temp\{76490AC9-C2E9-4CF1-A8D2-AFF8492F65C1}\ifc * Database version: 5507 * Database creation date: Mon Mar 01 13:49:56 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 01 13:49:56 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 01 13:49:56 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 7405 Shower system, 160cc, 7405(2021):7405 Shower system, 160cc:368927
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - ShowerDefaultElevation: 900 mm
Type - Dimensions - NominalDepth: 545.692 mm; NominalHeight: 1162.51 mm; NominalWidth: 291.051 mm; Projection: 459 mm
Type - General - Author: BIMStone; BIMObjectName: 7405(2021); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 15/02/2021
Type - Green Building Properties - Backflow Prevention EN1717: EB; Customs Code: 84818011; EAN Number: 6414150098284; EN Standard: EN 1111
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/7405; Catalog Drawing URL: http://static.oras.com/catdrw/7405; Class: Thermostatic; Dimension Drawing URL: http://static.oras.com/dimdrw/7405; FDV Document URL: http://www.oras.com/datasheet/7405/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/7405; Group: Shower systems; Manufacturer: Oras; Market: INT;SWE; Model: 7405 Shower system, 160cc; Name_en: 7405 Shower system, 160cc; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 1154 x 383 x 98; Package Weight: 5.4 kg; Product Code: 7405; Product Datasheet: http://www.oras.com/datasheet/7405/en; Product Family: Oras Nova Style; Product Image URL: http://static.oras.com/image/7405; Product URL: http://static.oras.com/7405; Technical DataSheet URL: http://www.oras.com/datasheet/7405/en; Type Name: 7405 Shower system, 160cc
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Can be shortened; Connection: DirectConnection; Connection Size: M26x1.5; Diverter: Integrated diverter / Volume control; Flow Rate At 300kPa: 0.00918181 m3/s; Hand Shower Size: Ø 95 mm; Installation and Maintenance: http://static.oras.com/manual/7405; Installation Type: Wall mounted; Installation Width: CC160 mm; Lever Handle: Temperature control handle;Flow control handle; Max. Hot Water Supply: 65 kg/K/s3; Mechanical Parts: Ceramic head part;Non-return valve(s);Litter filter(s); Noise Class: I (ISO 3822); Not Included: WithoutCouplings; Over Head Shower Size: 200 mm; Pressure Loss With Flow 02ls: 180000 Pa; Shower Parts: Hand shower;Shower rail;Shower head;Shower bracket adjustable;Shower Hose (1750 mm);;Wall distance adjustable;;; Shower Spray: Classic;Regular refreshing;Relaxing soft; Shower Spray Number: 3spray; Spare Parts: http://static.oras.com/sp/7405; Temperature Adjustments: Thermostatic safety stop at 38°C;THERMO COOL
Type - Other - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Shower; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 7405(2021); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 7405; Name: 7405 Shower system, 160cc; ReplacementCost: n/a; Shape: Sculptured; Size: 290x545x1165 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 1.13518 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 20 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.184666 m3
Identity Data - Mark: 14
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 7405(2021): 7405 Shower system, 160cc; Family and Type: 7405(2021): 7405 Shower system, 160cc; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 7405(2021): 7405 Shower system, 160cc; Type Id: 7405(2021): 7405 Shower system, 160cc; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
